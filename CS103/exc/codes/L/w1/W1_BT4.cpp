/*------------------------------------------------------------------------
                              Thông tin cá nhân                            
--------------------------------------------------------------------------
-------------------------- Họ tên: Đào Minh Đức --------------------------
------------------------------ MSSV: 2159003 -----------------------------
-------------------------------- Bài tập 4 -------------------------------
------------------------------------------------------------------------*/


#include<stdio.h>
#include<string>
using namespace std;

/// -------------------------------------------------------------------------- ///
///                                    Basic                                   ///
/// -------------------------------------------------------------------------- ///

int main()
{
    printf("\n CCCCC\nCC    C\nCC\nCC\nCC    C\n CccccC\n  CCCC");
    return 0;
}

/// -------------------------------------------------------------------------- ///



/// -------------------------------------------------------------------------- ///
///                                   Matrix                                   ///
/// -------------------------------------------------------------------------- ///
///
string str = "";                // Output string
const int matrix_size = 25;

// 0: \n | 1: <space> | 2: 'c' | 3: 'C' | 4: 4*<space> | 6: 2*'C' | 8: 4*'c' | 12: 4*'C'
int matrix[matrix_size] = {0, 1,3,12,0, 6,4,3,0, 6,0, 6,0, 6,4,3,0, 1,3,8,3,0, 1,1,12};

int main()
{
    for (int i = 0; i <= matrix_size; i++)
    {
        int check = matrix[i];
        
        if (check == 0)
        {
            str += "\n";
        }

        else if(check == 1)
        {
            str += " ";
        }
        
        else if(check == 2)
        {
            str += "c";
        }
        
        else if(check == 3)
        {
            str += "C";
        }
        
        else if(check == 4)
        {
            str += "    ";
        }
        
        else if(check == 6)
        {
            str += "CC";
        }
        
        else if(check == 8)
        {
            str += "cccc";
        }
        
        else if(check == 12)
        {
            str += "CCCC";
        }

        else
        {
            printf("\nWrong input format: %d. Skip.", check);
            continue;
        }
    }

    printf("%s", str.c_str());
    return 0;
}///
/// -------------------------------------------------------------------------- ///